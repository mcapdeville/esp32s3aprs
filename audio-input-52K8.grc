options:
  parameters:
    author: CAPDEVILLE Marc (F4JMZ)
    comment: |-
      This program is free software: you can redistribute it and/or modify
      it under the terms of the GNU General Public License as published by
      the Free Software Foundation, either version 3 of the License, or
      (at your option) any later version.
    copyright: Copiright (C) 2025 CAPDEVILLE Marc (F4JMZ)
    description: 52800Hz UAC2 input streaming test application
    generate_options: qt_gui
    id: audio_input_52K8
    output_language: python
    title: ESPs2APRS-input
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '52800'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:ESP32s3APRS
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '528'
    fbw: '0.3'
    interp: '480'
    type: fff
  states: {}

connections:
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
